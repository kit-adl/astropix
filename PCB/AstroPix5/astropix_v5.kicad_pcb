# Repository kit-adl/astropix

File README.md:

# Astropix Repository

See PCB Folder for Altium designer project, and Astropix_v1_202004 for Astropix 1 Software and Nexys Video Firmware

## KiCad design PCB/AstroPix5/astropix_v5.kicad_pcb

Parts:
C1, C6, C8: 1nF; C_0603_1608Metric
C2, C9, C10: .1uF; C_0603_1608Metric
C3: 100 nF; C_0603_1608Metric
C4, C11, C13: 10uF; C_0603_1608Metric
C14: 1nF; C_1210_3225Metric; Voltage 250V
C15: .1uF; C_1210_3225Metric; Voltage 250V
FID3, FID4: Fiducial; Fiducial_1mm_Mask2mm
H4, H5: MountingHole; MountingHole_3.2mm_M3
H6: bonder
J1, J4, J5: HBOut; SMA_Molex_73251-2200_Horizontal
J2: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J3: pcie_GECCO; BUS_PCIexpress_x16
J7: HV_in_external; SMA_Molex_73251-2200_Horizontal
J8: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J12: Measures_Analog; PinHeader_1x04_P2.54mm_Vertical
J14: Bias; PinHeader_1x12_P2.54mm_Horizontal
JP3: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
JP4, JP5: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
Logo4: KIT_logo; logo
Logo5, Logo6: HV_logo; hv
R1: 1k; R_0603_1608Metric
R2, R3: 2k2; R_0603_1608Metric
R4, R6: 10k; R_0603_1608Metric
TP1, TP2: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U2: AstroPix5_split_powerring; AstroPix5_v2

Connections:
/Clk20_Ext_N: J3.B43 (FMC_LA14_N), U2.B43 (Clk20_Ext_N)
/Clk20_Ext_P: J3.B42 (FMC_LA14_P), U2.B42 (Clk20_Ext_P)
/DigInj: J3.B51 (FMC_LA06_N), U2.B93 (DigInj)
/Enable_SPI_diff: J3.A21 (FMC_LA19_N), U2.B25 (Enable_SPI_diff)
/HV_in_ext: J7.1 (In), R1.1
/Inj: J3.A28 (C3_1), U2.B72 (Inj)
/SPI_CLK_N: J3.A41 (FMC_LA15_N), U2.B36 (SPI_CLK_N)
/SPI_CLK_P: J3.A40 (FMC_LA15_P), U2.B35 (SPI_CLK_P)
/SPI_CSN_N: J3.B23 (FMC_LA18_CC_N), U2.B38 (SPI_CSN_N)
/SPI_CSN_P: J3.B22 (FMC_LA18_CC_P), U2.B37 (SPI_CSN_P)
/SPI_MISO0_N: J3.B41 (FMC_LA16_N), U2.B31 (SPI_MISO0_N)
/SPI_MISO0_P: J3.B40 (FMC_LA16_P), U2.B30 (SPI_MISO0_P)
/SPI_MISO1_N: J3.B19 (FMC_LA22_N), U2.B29 (SPI_MISO1_N)
/SPI_MISO1_P: J3.B18 (FMC_LA22_P), U2.B28 (SPI_MISO1_P)
/SPI_MOSI_N: J3.B21 (FMC_LA20_N), U2.B34 (SPI_MOSI_N)
/SPI_MOSI_P: J3.B20 (FMC_LA20_P), U2.B33 (SPI_MOSI_P)
/SPI_left_CLK: J3.A17 (FMC_LA23_N), U2.L4 (SPI_left_CLK)
/SPI_left_CSN: J3.A16 (FMC_LA23_P), U2.L5 (SPI_left_CSN)
/SPI_left_MISO0: J3.A18 (FMC_LA21_P), U2.L2 (SPI_left_MISO0)
/SPI_left_MISO1: J3.A19 (FMC_LA21_N), U2.L1 (SPI_left_MISO1)
/SPI_left_MOSI: J3.A20 (FMC_LA19_P), U2.L3 (SPI_left_MOSI)
/SPI_right_CLK: J3.A52 (FMC_LA03_P), U2.R2 (SPI_right_CLK)
/SPI_right_CSN: J3.A53 (FMC_LA03_N), U2.R1 (SPI_right_CSN)
/SPI_right_MISO0: J3.A50 (FMC_LA05_P), U2.R4 (SPI_right_MISO<0>)
/SPI_right_MISO1: J3.A49 (FMC_LA07_N), U2.R5 (SPI_right_MISO<1>)
/SPI_right_MOSI: J3.A51 (FMC_LA05_N), U2.R3 (SPI_right_MOSI)
/SR_ck1: J3.A42 (FMC_LA13_P), J3.B48 (FMC_LA08_P), U2.B50 (SR_ck1)
/SR_ck2: J3.A43 (FMC_LA13_N), J3.B49 (FMC_LA08_N), U2.B51 (SR_ck2)
/SR_ldpatgen: J3.A44 (FMC_LA11_P), U2.B56 (SR_ldpatgen)
/SR_ldtdac: J3.A47 (FMC_LA09_N), U2.B55 (SR_ldtdac)
/SR_load: J3.B53 (FMC_LA04_N), J3.B54 (FMC_LA02_P), U2.B52 (SR_load)
/SR_out_0D: J3.B17 (FMC_LA24_N), U2.B21 (SR_out_OD)
/SR_out_CK1: J3.B16 (FMC_LA24_P), U2.B22 (SR_out_CK1)
/SR_rb: J3.A45 (FMC_LA11_N), U2.B54 (SR_rb)
/SR_sin: J3.B44 (FMC_LA12_P), J3.B50 (FMC_LA06_P), U2.B53 (SR_sin)
/SR_sout: J3.A46 (FMC_LA09_P), U2.B57 (SR_sout)
/ThPix: J3.B33 (C4_3), J14.6, U2.B74 (ThPix)
/VCasc2!: J3.B34 (C4_8), J14.8, U2.B81 (VCasc2!)
/blpix: J3.B32 (C4_4), J14.2, U2.B68 (blpix)
/hold: J3.B47 (FMC_LA10_N), U2.B49 (hold)
/interrupt: J3.B52 (FMC_LA04_P), J8.1, R4.1, U2.B46 (interrupt)
/res_n: J3.B46 (FMC_LA10_P), U2.B47 (res_n)
/syncres: J3.B45 (FMC_LA12_N), U2.B48 (syncres)
/timestamp_clk: J3.A23 (FMC_LA17_CC_N), U2.B41 (timestamp_clk)
/vminuspix: J3.B35 (C4_7), R6.2, U2.B98 (vminuspix)
GND: C1.2, C2.2, C3.1, C4.2, C6.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.1, C15.1, J1.2 (Ext), J3.A11 (GND), J3.B11 (GND), J4.2 (Ext), J5.2 (Ext), J7.2 (Ext), J8.3, J12.4, J14.11, JP3.1 (A), JP4.1 (A), JP5.1 (A), R2.2, R3.2, U2.GNDA_Ring (gnda!), U2.GND_Ring (gnd!)
unnamed: J1.1 (In), R2.1, U2.B77 (ampout)
unnamed: J2.1, U2.L10 (pring0)
unnamed: J2.2, U2.L9 (pring1)
unnamed: J2.3, U2.L8 (pring2)
unnamed: J2.4, U2.L7 (pring3)
unnamed: J2.5, U2.L6 (pring4)
unnamed: J4.1 (In), U2.B24 (pll_clk)
unnamed: J5.1 (In), R3.1, U2.B40 (HBOut)
unnamed: J12.1, U2.B84 (Vtemp1)
unnamed: J12.2, U2.B85 (Vtemp2)
unnamed: J14.1, U2.B67 (pamp)
unnamed: J14.3, U2.B66 (VPBias!)
unnamed: J14.4, U2.B69 (pload)
unnamed: J14.5, U2.B23 (vpDel)
unnamed: J14.10, U2.B86 (cascpix)
unnamed: J14.12, U2.B96 (vminusref)
unnamed: JP3.2 (C), U2.B6 (dnring)
unnamed: JP4.2 (B), U2.B7 (pring_pixel)
unnamed: JP5.2 (B), U2.B3 (chipring)
unnamed: TP1.1, U2.B78 (Qdac<0>)
unnamed: TP2.1, U2.B79 (Qdac<1>)
unnamed: C3.2, U2.B20 (VGateComp!)
unnamed: R6.1, U2.B97 (vminusout)
VDD: C1.1, C2.1, C4.1, J3.B5 (POW4), J3.B6 (POW4), R4.2, U2.VDD_Ring (vdd!)
VDDA: C8.1, C10.1, C13.1, J3.B7 (POW6), J3.B8 (POW6), JP3.3 (B), U2.VDDA_Ring (vdda!)
VSSA: C6.1, C9.1, C11.1, J3.A5 (VSSA), J3.A6 (VSSA), U2.VSSA_Ring (vssa!)
suba: C14.2, C15.2, R1.2, U2.B4 (sub!), U2.B5 (sub!)

Notes on the sheet:
If injection card is not used
Injectioncard (backup)
Voltagecard (backup)
Voltagecard
Configcard (backup)

Board: 4 copper layers, 56.4 x 74.0 mm, 39 parts (0 on the bottom side), 73 nets.

## KiCad design PCB/AstroPix4/astropix_v4.kicad_pcb

Parts:
C1, C8, C11: 1nF; C_0603_1608Metric
C2, C9, C13: .1uF; C_0603_1608Metric
C4: 1nF; C_1210_3225Metric; Voltage 250V
C6: .1uF; C_1210_3225Metric; Voltage 250V
C10, C14, C15: 10uF; C_0603_1608Metric
FID1, FID2: Fiducial; Fiducial_1mm_Mask2mm
H1, H2: MountingHole; MountingHole_3.2mm_M3
H3: bonder
J1: pcie_GECCO; pcie_astropix
J2: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J4: SFOut; SMA_Molex_73251-2200_Horizontal
J6: HV_in_external; SMA_Molex_73251-2200_Horizontal
J8: HBOut; SMA_Molex_73251-2200_Horizontal
J9: SPI_left; PinHeader_1x06_P2.54mm_Vertical
J10: SPI_right; PinHeader_1x06_P2.54mm_Vertical
J11: HV; PinHeader_1x05_P2.54mm_Vertical
JP1: VDD_JP; PinHeader_1x03_P2.54mm_Vertical
Logo1: KIT_logo; logo
Logo2, Logo3: HV_logo; hv
R1, R2: 2.2k; R_0603_1608Metric
R10, R13, R14, R17, R18: 22; R_0402_1005Metric
R12: 1k; R_0603_1608Metric
U1: AstroPix4_split_powerring; AstroPix4

Connections:
/DAC_ThPix: J1.B34 (C4_8), U1.B46 (ThPix)
/DAC_VCasc2!: J1.B33 (C4_3), U1.B54 (Vcasc2!)
/DAC_blpix: J1.B32 (C4_4), U1.B40 (blpix)
/DAC_vminuspix: J1.B35 (C4_7), J1.B39 (C5_7), U1.B47 (vminuspix)
/DigInj: J1.B40 (FMC_LA16_P), U1.B68 (DigInj)
/HV_in_ext: J6.1 (In), R12.1
/Inj: J1.A28 (C3_1), U1.B44 (Inj)
/POW4_in: J1.B5 (POW4), J1.B6 (POW4), JP1.3 (B)
/VDD18_in: J1.B3 (VDD18), J1.B4 (VDD18), JP1.1 (A)
/VPBias: J2.4, U1.B38 (VPBias)
/Vtemp1: J2.1, U1.B57 (Vtemp1)
/Vtemp2: J2.3, U1.B58 (Vtemp2)
/cascpix: J2.8, U1.B59 (cascpix)
/clk20_N: J1.B19 (FMC_LA22_N), U1.B15 (clk20_N)
/clk20_P: J1.B18 (FMC_LA22_P), U1.B14 (clk20_P)
/hold: J1.B20 (FMC_LA20_P), U1.B21 (hold)
/interrupt: J1.B22 (FMC_LA18_CC_P), U1.B18 (interrupt)
/pamp: J2.6, U1.B39 (pamp)
/pload: J2.2, U1.B41 (pload)
/res_n: J1.B23 (FMC_LA18_CC_N), U1.B19 (res_n)
/spi_left_clk: J1.A17 (FMC_LA23_N), J9.4, U1.L4 (spi_left_CLK)
/spi_left_csn: J1.A16 (FMC_LA23_P), J9.5, R14.2
/spi_left_miso0: J1.A19 (FMC_LA21_N), J9.2, R13.2
/spi_left_miso1: J1.A18 (FMC_LA21_P), J9.3, R10.2
/spi_left_mosi: J1.A20 (FMC_LA19_P), J9.1, U1.L3 (spi_left_MOSI)
/spi_right_clk: J1.A40 (FMC_LA15_P), J10.1, R18.1
/spi_right_csn: J1.A43 (FMC_LA13_N), J10.4, U1.R1 (spi_right_CSN)
/spi_right_miso0: J1.A42 (FMC_LA13_P), J10.3, U1.R4 (spi_right_MISO<0>)
/spi_right_miso1: J1.A41 (FMC_LA15_N), J10.2, U1.R5 (spi_right_MISO<1>)
/spi_right_mosi: J1.A44 (FMC_LA11_P), J10.5, R17.1
/sr_ck1: J1.A24 (C2_1), J1.B42 (FMC_LA14_P), U1.B22 (sr_CK1)
/sr_ck2: J1.A25 (C2_2), J1.B43 (FMC_LA14_N), U1.B23 (sr_CK2)
/sr_ld: J1.B24 (C2_4), J1.B44 (FMC_LA12_P), U1.B24 (sr_LOAD)
/sr_ldtdac: J1.A21 (FMC_LA19_N), U1.B27 (sr_LdTDAC)
/sr_out: J1.A22 (FMC_LA17_CC_P), U1.B28 (sr_SOUT)
/sr_rb: J1.A23 (FMC_LA17_CC_N), U1.B26 (sr_RB)
/sr_sin: J1.B25 (C2_3), J1.B45 (FMC_LA12_N), U1.B25 (sr_SIN)
/timestamp_clk: J1.B21 (FMC_LA20_N), U1.B20 (clkTS)
/vdac_test: J2.5, U1.B60 (Vdac_test)
GND: C1.2, C2.2, C4.1, C6.1, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, J1.A11 (GND), J1.B11 (GND), J2.7, J4.2 (Ext), J6.2 (Ext), J8.2 (Ext), J9.6, J10.6, R1.2, R2.2, U1.B6 (gnda!), U1.B8 (gnda!), U1.B12 (gnda!), U1.B17 (gnd!), U1.B29 (gnd!), U1.B31 (gnd!), U1.B37 (gnda!), U1.B42 (gnda!), U1.B45 (gnda!), U1.B48 (gnda!), U1.B56 (gnda!), U1.B63 (gnda!), U1.B66 (gnda!), U1.B70 (gnd!)
unnamed: J4.1 (In), R2.1, U1.B50 (ampout)
unnamed: J8.1 (In), R1.1, U1.B13 (HB)
unnamed: J11.1, U1.B1 (sub!)
unnamed: J11.3, U1.B3 (floating_ring)
unnamed: J11.5, U1.B4 (dn_ring)
unnamed: R14.1, U1.L5 (spi_left_CSN)
unnamed: R13.1, U1.L2 (spi_left_MISO0)
unnamed: R10.1, U1.L1 (spi_left_MISO1)
unnamed: R18.2, U1.R2 (spi_right_CLK)
unnamed: R17.2, U1.R3 (spi_right_MOSI)
VDD: C8.1, C9.1, C10.1, JP1.2 (C), U1.VDDD_Ring (vdd!)
VDDA: C11.1, C13.1, C14.1, J1.B7 (POW6), J1.B8 (POW6), J11.4, U1.VDDA_Ring (vdda!)
VSSA: C1.1, C2.1, C15.1, J1.A5 (VSSA), J1.A6 (VSSA), U1.VSSA_Ring (vssa!)
suba: C4.2, C6.2, R12.2, U1.B71 (hv_ring)

Notes on the sheet:
If injection card is not used
Configcard (backup)
Pullup in fpga
internal switchable 100Ohm diff termination
Voltagecard (backup)
Injectioncard (backup)
Connect dnring to 1.8V to collect leakage current
Voltagecard

Board: 4 copper layers, 51.3 x 57.3 mm, 37 parts (0 on the bottom side), 54 nets.
