# Repository kit-adl/astropix (continued)

## KiCad design PCB/AstroPix3/astropix_v3.kicad_pcb

Parts:
C1, C8, C11: 1nF; C_0603_1608Metric
C2, C7, C9, C12, C13: .1uF; C_0603_1608Metric
C4: 1nF; C_1210_3225Metric; Voltage 250V
C6: .1uF; C_1210_3225Metric; Voltage 250V
C10, C14, C15: 10uF; C_0603_1608Metric
FID1, FID2: Fiducial; Fiducial_1mm_Mask2mm
H1, H2: MountingHole; MountingHole_3.2mm_M3
H3: bonder
J1: pcie_GECCO; pcie_astropix
J2: ChipRings; PinHeader_1x04_P2.54mm_Vertical
J3: TempSens; PinHeader_1x05_P2.54mm_Vertical
J4: SFOut; SMA_Molex_73251-2200_Horizontal
J5: sample_clock_out; SMA_Molex_73251-2200_Horizontal
J6: HV_in_external; SMA_Molex_73251-2200_Horizontal
J7: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J9: SPI_left; PinHeader_1x06_P2.54mm_Vertical
J10: SPI_right; PinHeader_1x06_P2.54mm_Vertical
JP1: VDD_JP; PinHeader_1x03_P2.54mm_Vertical
Logo1: KIT_logo; logo
Logo2: HV_logo; hv
R2: 2.2k; R_0603_1608Metric
R3, R4: 100; R_0402_1005Metric
R5: 10k; R_0603_1608Metric
R6, R9, R15, R16, R19: 220k; R_0603_1608Metric
R8, R10, R13, R14, R17, R18: 22; R_0402_1005Metric
R11: 0; R_0603_1608Metric
R12: 1k; R_0603_1608Metric
U2: SN65LVDS4; Texas_R-PUQFN-N10
U5: AstroPix3_split; AstroPix3_power2

Connections:
/DAC_ThPMOS: J1.A32 (C4_1), U5.B77 (ThPMOS)
/DAC_ThPix: J1.B34 (C4_8), U5.B58 (ThPix)
/DAC_VCasc2!: J1.B33 (C4_3), U5.B70 (Vcasc2!)
/DAC_blpix: J1.B32 (C4_4), U5.B52 (blpix)
/DAC_vminuspix: J1.B35 (C4_7), U5.B59 (vminuspix)
/DigInj: J1.B40 (FMC_LA16_P), U5.B84 (DigInj)
/HV_in_ext: J6.1 (In), R12.1
/Inj: J1.A28 (C3_1), U5.B56 (Inj)
/POW4_in: J1.B5 (POW4), J1.B6 (POW4), JP1.3 (B)
/VDD18_in: J1.B3 (VDD18), J1.B4 (VDD18), JP1.1 (A)
/hold: J1.B20 (FMC_LA20_P), U5.B33 (hold)
/interrupt: J1.B22 (FMC_LA18_CC_P), U5.B30 (interrupt)
/res_n: J1.B23 (FMC_LA18_CC_N), R5.2, U5.B31 (res_n)
/ring1: J2.1, R6.2, R9.1, U5.B90 (ring1)
/ring2: J2.2, R9.2, R15.1, U5.B89 (ring2)
/ring3: J2.3, R15.2, R16.1, U5.B88 (ring3)
/ring4: J2.4, R16.2, R19.1, U5.B87 (ring4)
/sample_clock_N: J1.B19 (FMC_LA22_N), R4.2, U5.B27 (sample_clock_n)
/sample_clock_P: J1.B18 (FMC_LA22_P), R4.1, U5.B26 (sample_clock_p)
/sample_clock_se_N: J1.B17 (FMC_LA24_N), R3.2, U2.3 (IN-)
/sample_clock_se_P: J1.B16 (FMC_LA24_P), R3.1, U2.2 (IN+)
/sample_clock_se_in: U2.8 (OUT), U5.L6 (sample_clock_left)
/sc_out: J5.1 (In), R8.1
/spi_left_clk: J1.A17 (FMC_LA23_N), J9.4, U5.L4 (SPI_left_CLK)
/spi_left_csn: J1.A16 (FMC_LA23_P), J9.5, R14.2
/spi_left_miso0: J1.A19 (FMC_LA21_N), J9.2, R13.2
/spi_left_miso1: J1.A18 (FMC_LA21_P), J9.3, R10.2
/spi_left_mosi: J1.A20 (FMC_LA19_P), J9.1, U5.L3 (SPI_left_MOSI)
/spi_right_clk: J1.A40 (FMC_LA15_P), J10.1, R18.1
/spi_right_csn: J1.A43 (FMC_LA13_N), J10.4, U5.R2 (SPI_right_CSN)
/spi_right_miso0: J1.A42 (FMC_LA13_P), J10.3, U5.R5 (SPI_right_MISO0)
/spi_right_miso1: J1.A41 (FMC_LA15_N), J10.2, U5.R6 (SPI_right_MISO1)
/spi_right_mosi: J1.A44 (FMC_LA11_P), J10.5, R17.1
/sr_ck1: J1.A24 (C2_1), U5.B34 (sr_CK1)
/sr_ck2: J1.A25 (C2_2), U5.B35 (sr_CK2)
/sr_ld: J1.B24 (C2_4), U5.B36 (sr_LOAD)
/sr_out: J1.A22 (FMC_LA17_CC_P), U5.B39 (sr_SOUT)
/sr_rb: J1.A23 (FMC_LA17_CC_N), U5.B38 (sr_RB)
/sr_sin: J1.B25 (C2_3), U5.B37 (sr_SIN)
/timestamp_clk: J1.B21 (FMC_LA20_N), U5.B32 (timestamp_clk)
GND: C1.2, C2.2, C4.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, J1.A11 (GND), J1.B11 (GND), J3.5, J4.2 (Ext), J5.2 (Ext), J6.2 (Ext), J7.2, J9.6, J10.6, R2.2, U2.1 (GND), U2.7 (GND), U5.B9 (gnda!), U5.B11 (gnda!), U5.B15 (gnda!), U5.B17 (gnda!), U5.B21 (gnda!), U5.B23 (gnda!), U5.B29 (gnd!), U5.B41 (gnd!), U5.B48 (gnda!), U5.B49 (gnda!), U5.B54 (gnda!), U5.B57 (gnda!), U5.B60 (gnda!), U5.B67 (gnda!), U5.B73 (gnda!), U5.B80 (gnda!), U5.B83 (gnda!), U5.B86 (gnd!)
unnamed: J3.1, U5.B68 (Vtemp0)
unnamed: J3.2, U5.B69 (Vtemp1)
unnamed: J3.3, U5.B74 (Vtemp2)
unnamed: J3.4, U5.B75 (Vtemp3)
unnamed: J4.1 (In), R2.1, U5.B62 (ampout)
unnamed: J7.1, R6.1
unnamed: J7.3, R19.2
unnamed: R8.2, U5.R1 (sample_clock_right)
unnamed: R10.1, U5.L1 (SPI_left_MISO1)
unnamed: R11.2, U5.B5 (subpixels)
unnamed: R13.1, U5.L2 (SPI_left_MISO0)
unnamed: R14.1, U5.L5 (SPI_left_CSN)
unnamed: R17.2, U5.R4 (SPI_right_MOSI)
unnamed: R18.2, U5.R3 (SPI_right_CLK)
VDD: C7.1, C8.1, C9.1, C10.1, C12.1, JP1.2 (C), R5.1, U2.5 (VCC), U2.10 (VDD), U5.VDDD_Ring
VDDA: C11.1, C13.1, C14.1, J1.B7 (POW6), J1.B8 (POW6), U5.VDDA_Ring
VSSA: C1.1, C2.1, C15.1, J1.A5 (VSSA), J1.A6 (VSSA), U5.VSSA_Ring
suba: C4.2, C6.2, R11.1, R12.2, U5.B0 (sub!), U5.B1 (sub!), U5.B2 (sub!), U5.B3 (sub!), U5.B4 (sub!), U5.B91 (sub!), U5.B92 (sub!), U5.B93 (sub!), U5.B94 (sub!)

Notes on the sheet:
Configcard
Pullup in fpga
100 Ohm Term opt. Failsafe R13=2k R14=4k
Voltagecard
Injectioncard

Board: 4 copper layers, 51.3 x 57.3 mm, 49 parts (0 on the bottom side), 59 nets.

## KiCad design PCB/AstroPix2/astropix_v2.kicad_pcb

Parts:
C1, C2, C7, C9, C12, C13: .1uF; C_0603_1608Metric
C3, C4: 1nF; C_1210_3225Metric; Voltage 250V
C5, C6: .1uF; C_1210_3225Metric; Voltage 250V
C8, C11: 1nF; C_0603_1608Metric
C10, C14: 10uF; C_0603_1608Metric
FID1, FID2: Fiducial; Fiducial_1mm_Mask2mm
H1, H2: MountingHole; MountingHole_3.2mm_M3
H3: bonder
J1: pcie_GECCO; pcie_astropix
J3: Vtemp1; SMA_Molex_73251-2200_Horizontal
J4: SFOut; SMA_Molex_73251-2200_Horizontal
J5: sample_clock_out; SMA_Molex_73251-2200_Horizontal
J6: HV_in_external; SMA_Molex_73251-2200_Horizontal
J9: SPI_left; PinHeader_1x06_P2.54mm_Vertical
J10: SPI_right; PinHeader_1x06_P2.54mm_Vertical
JP1: VDD_JP; PinHeader_1x03_P2.54mm_Vertical
Logo1: KIT_logo; logo
Logo2: HV_logo; hv
R1: 0; R_1206_3216Metric
R2, R6: 47; R_0603_1608Metric
R3, R4: 100; R_0402_1005Metric
R5, R7: 10k; R_0603_1608Metric
R8, R10, R13, R14, R17, R18: 22; R_0402_1005Metric
R9, R11, R12: 1k; R_0603_1608Metric
R15, R16: 2.2k; R_0603_1608Metric
U1: TLV333; SOT-23-6
U2: SN65LVDS4; Texas_Instruments-SN65LVDS4RSET-0
U3: OPA320S; SOT-23-6
U4: AstroPix2_split; AstroPix2

Connections:
-HV: J1.A1 (HV), J1.B1 (HV), R1.2
/DAC_ThPix: J1.B34 (C4_8), U4.B32 (ThPix)
/DAC_VCasc2!: J1.B33 (C4_3), U4.B31 (VCasc2!)
/DAC_blpix: J1.B32 (C4_4), U4.B26 (blpix)
/DAC_vminuspix: J1.B35 (C4_7), U4.B33 (vminuspix)
/HV_in_ext: J6.1 (In), R1.1, R11.1, R12.1
/Inj: J1.A28 (C3_1), U4.B30 (Inj)
/POW4_in: J1.B5 (POW4), J1.B6 (POW4), JP1.3 (B)
/SFOut: U3.3 (+), U4.B36 (SFOut)
/VDD18_in: J1.B3 (VDD18), J1.B4 (VDD18), JP1.1 (A)
/Vtemp1: R9.2, U4.B39 (Vtemp1)
/hold: J1.B20 (FMC_LA20_P), U4.B9 (interrupt)
/interrupt: J1.B22 (FMC_LA18_CC_P), R7.2, U4.B12 (hold)
/res_n: J1.B23 (FMC_LA18_CC_N), R5.2, U4.B10 (res_n)
/sample_clock_N: J1.B19 (FMC_LA22_N), R4.2, U4.B6 (sample_clock_n)
/sample_clock_P: J1.B18 (FMC_LA22_P), R4.1, U4.B5 (sample_clock_p)
/sample_clock_se_N: J1.B17 (FMC_LA24_N), R3.2, U2.3 (IN-)
/sample_clock_se_P: J1.B16 (FMC_LA24_P), R3.1, U2.2 (IN+)
/sample_clock_se_in: U2.8 (OUT), U4.L6 (sample_clock_left)
/sc_out: J5.1 (In), R8.1
/spi_left_clk: J1.A17 (FMC_LA23_N), J9.4, U4.L4 (SPI_left_CLK)
/spi_left_csn: J1.A16 (FMC_LA23_P), J9.5, R14.2
/spi_left_miso0: J1.A19 (FMC_LA21_N), J9.2, R13.2
/spi_left_miso1: J1.A18 (FMC_LA21_P), J9.3, R10.2
/spi_left_mosi: J1.A20 (FMC_LA19_P), J9.1, U4.L3 (SPI_left_MOSI)
/spi_right_clk: J1.A40 (FMC_LA15_P), J10.1, R18.1
/spi_right_csn: J1.A43 (FMC_LA13_N), J10.4, U4.R2 (SPI_right_CSN)
/spi_right_miso0: J1.A42 (FMC_LA13_P), J10.3, U4.R5 (SPI_right_MISO0)
/spi_right_miso1: J1.A41 (FMC_LA15_N), J10.2, U4.R6 (SPI_right_MISO1)
/spi_right_mosi: J1.A44 (FMC_LA11_P), J10.5, R17.1
/sr_ck1: J1.A24 (C2_1), U4.B13 (sr_CK1)
/sr_ck2: J1.A25 (C2_2), U4.B14 (sr_CK2)
/sr_ld: J1.B24 (C2_4), U4.B15 (sr_LOAD)
/sr_out: J1.A22 (FMC_LA17_CC_P), U4.B18 (sr_SOUT)
/sr_rb: J1.A23 (FMC_LA17_CC_N), U4.B17 (sr_RB)
/sr_sin: J1.B25 (C2_3), U4.B16 (sr_SIN)
/timestamp_clk: J1.B21 (FMC_LA20_N), U4.B11 (timestamp_clk)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.A11 (GND), J1.B11 (GND), J3.2 (Ext), J4.2 (Ext), J5.2 (Ext), J6.2 (Ext), J9.6, J10.6, R15.2, U1.2 (V-), U2.1 (GND), U2.7 (GND), U3.2 (V-), U4.B3 (gnda!), U4.B8 (gnd!), U4.B20 (gnd!), U4.B22 (gnda!), U4.B23 (gnda!), U4.B28 (gnda!), U4.B34 (gnda!), U4.B38 (gnda_temp), U4.Ring1
unnamed: J3.1 (In), R2.1
unnamed: J4.1 (In), R6.1
unnamed: R6.2, U3.1, U3.4 (-)
unnamed: R8.2, U4.R1 (sample_clock_right)
unnamed: R9.1, U1.3 (+)
unnamed: R10.1, U4.L1 (SPI_left_MISO1)
unnamed: R13.1, U4.L2 (SPI_left_MISO0)
unnamed: R14.1, U4.L5 (SPI_left_CSN)
unnamed: R15.1, R16.1, U1.4 (-)
unnamed: R2.2, R16.2, U1.1
unnamed: R17.2, U4.R4 (SPI_right_MOSI)
unnamed: R18.2, U4.R3 (SPI_right_CLK)
VDD: C7.1, C8.1, C9.1, C10.1, C12.1, JP1.2 (C), R5.1, R7.1, U2.5 (VCC), U2.10 (VDD), U4.B7 (vdd!), U4.B19 (vdd!)
VDDA: C1.1, C2.1, C11.1, C13.1, C14.1, J1.B7 (POW6), J1.B8 (POW6), U1.5 (~PD), U1.6 (V+), U3.5 (~PD), U3.6 (V+), U4.B4 (vdda!), U4.B21 (vdda!), U4.B29 (vdda!), U4.B35 (vdda!), U4.B37 (vdda_temp)
suba: C4.2, C6.2, R12.2, U4.B0 (PAD), U4.B40 (sub), U4.B41 (subapads), U4.B42 (ring1), U4.B43 (ring2), U4.B44 (ring3), U4.B45 (ring4)
subd: C3.2, C5.2, R11.2, U4.B1 (sub), U4.B2 (subdpads)

Notes on the sheet:
PCB compatible to: OPA320S SOT-23-6 OPA320 SOT-23-5
100 Ohm Term opt. Failsafe R13=2k R14=4k
Voltagecard
Injectioncard
Configcard
GECCO HV Clearance?

Board: 4 copper layers, 51.3 x 57.3 mm, 51 parts (0 on the bottom side), 54 nets.

## Code that names these connections

File FW/AstroPix3/GECCO_Firmware.src/constraints/NexysVideo_Master.xdc (part):

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#set_property -dict { PACKAGE_PIN F14   IOSTANDARD LVDS_25 } [get_ports { config_ck2_n }]; #IO_L1N_T0_16 Sch=fmc_la_n[33]
#set_property -dict { PACKAGE_PIN F13   IOSTANDARD LVDS_25 } [get_ports { config_ck2_p }]; #IO_L1P_T0_16 Sch=fmc_la_p[33]

set_property -dict {PACKAGE_PIN C17 IOSTANDARD LVCMOS25} [get_ports res_n]

set_property -dict {PACKAGE_PIN F20 IOSTANDARD LVCMOS25} [get_ports timestamp_clk]

# Reverse hold <-> interrupt switch from V2
set_property -dict {PACKAGE_PIN F19 IOSTANDARD LVCMOS25} [get_ports hold]; #IO_L18P_T2_16 Sch=fmc_la_p[20]
set_property -dict {PACKAGE_PIN D17 IOSTANDARD LVCMOS25} [get_ports interrupt]; #IO_L12P_T1_MRCC_16 Sch=fmc_la18_cc_p

set_property -dict {PACKAGE_PIN D21 IOSTANDARD LVDS_25} [get_ports sample_clk_n]
set_property -dict {PACKAGE_PIN E21 IOSTANDARD LVDS_25} [get_ports sample_clk_p]
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# end

#SPI left
set_property -dict {PACKAGE_PIN A21 IOSTANDARD LVCMOS25} [get_ports spi_left_clk]
set_property -dict {PACKAGE_PIN B21 IOSTANDARD LVCMOS25} [get_ports spi_left_csn]
set_property -dict {PACKAGE_PIN D19 IOSTANDARD LVCMOS25} [get_ports spi_left_miso0]
set_property -dict {PACKAGE_PIN E19 IOSTANDARD LVCMOS25} [get_ports spi_left_miso1]
set_property -dict {PACKAGE_PIN A18 IOSTANDARD LVCMOS25} [get_ports spi_left_mosi]

#SPI right
set_property -dict {PACKAGE_PIN L14 IOSTANDARD LVCMOS25} [get_ports spi_right_mosi]
set_property -dict {PACKAGE_PIN J17 IOSTANDARD LVCMOS25} [get_ports spi_right_csn]
set_property -dict {PACKAGE_PIN K17 IOSTANDARD LVCMOS25} [get_ports spi_right_miso0]
set_property -dict {PACKAGE_PIN K16 IOSTANDARD LVCMOS25} [get_ports spi_right_miso1]
set_property -dict {PACKAGE_PIN L16 IOSTANDARD LVCMOS25} [get_ports spi_right_clk]

#END Astropix FMC
#set_property -dict { PACKAGE_PIN B16   DIFF_TERM TRUE } [get_ports {data_fmc_n}];
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
## Commit log (part)

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2020-10-14 Add README.md
2020-10-14 Added .gitignore
2020-10-16 Revert "Initial Commit"
    This reverts commit 8b2bdda9091a5f855757eecee505cb18b3ecec8b.
2020-10-18 Astropix Lib update
2020-10-18 Revert "Astropix Lib update"
    This reverts commit 4b748034e6318753e34dd6f0b782b1aa18e83a46.
2020-10-19 Added SN65LVDS4 lib
2020-10-19 Added correct I/O type to symbol
2020-10-20 Added Software for Astropix v1 initial commit
2020-10-21 finalized astropix footprint and Schematic
2020-10-21 Added Modified sympol with Gecco pinout
2020-10-21 Updated schematic and pcb with new symbols/footprints
2020-10-21 Softwre: Restored Chip config UI elements
2020-10-21 Initial Commit of firmware project
2020-10-21 Made nicer PCI connector symbol
2020-10-21 Updated PCI connector symbol
2020-10-21 Layout update
2020-10-21 Move Altium Project to PCB Folder
2020-10-21 remove old files
2020-10-21 add netclasses diff, Analog, HV and Power
2020-10-27 Add generic sot23-5 opamp lib
2020-10-27 Updated chip lib
2020-10-27 Updated Layout and Schematic
2020-10-27 Updated GUI Integration and tested injection
2020-10-27 Added final chip footprint
2020-10-27 Layout update, small Schematic fixes
2020-10-27 Added mounting holes for chip cover
2020-10-27 Added LVDS Rterm
2020-10-29 Add AD8024 to lib
2020-10-29 Resize PCB
2020-10-29 Small cosmetic Fixes
2020-10-30 Change Opamp LMP7715 -> OPA320
2020-10-30 Added Bondplan Footprint, fixed left side pads Y Position
2020-10-30 connected AD8024 Disable to FMC, small layout improvements
2020-10-30 Updated Projectfile
2020-10-30 Updated Astropix chip lib with bondplan footprint
2020-10-30 Updated Parts from library
2020-10-30 Added Bondplan PCB
2020-10-30 Removed Bondplan PCB from Project
2020-11-02 Removed Bondwires to unconnected Pads
2020-11-02 Add Variant with unplaced components and Bom
2020-11-02 BOM Update
2020-11-02 Added Variant
2020-11-02 Changed diff Impedance of Sample_CLK to 100 Ohm
2020-11-03 Carrier Bondplan als PDF
2020-11-04 Rearrange Ad8024 Input Components(TODO: Cutout internal planes to reduce stray capacitance)
2020-11-05 Added coutouts under AD8024 Inputs
2020-11-05 Improved OPA320 Layout
2020-11-06 Added short readme regarsing QT install
2020-11-06 Added PDF Output job file
2020-11-06 Readded README for QT software install, removed from QT project definition (was nonsense)
2020-11-06 wider hv bondpad
2020-11-06 Updated VB and Injection to Slots 4/5 , fixed display to DAC tabs
2020-11-06 Removed Silkscreen frame around Chip
2020-11-18 Sch: Changed Capacitances to appropriate values
2021-01-20 Added Astropix Digital Configbits, IDACs and Voltageboard DACS
2021-01-20 Readout Software: Greyed out unused widgets
2021-01-20 Crude TestFirmware with FMC_LA(18,20,22,24) changed to Astropix I/O.
2021-01-20 Don't create Widget for unused DAC
2021-01-21 Correct Pin Order for Chip SR write
2021-01-22 Software: modifying GUI building function ordering to simplify load config code
2021-01-22 Software: Fixed Configuration of ASIC is send reversed
2021-01-22 Software: Added ASIC SR bit debugging
2021-01-22 Softxare: Checkboxes were not updating the internal values correctly
2021-01-22 Software: Config write was missing load and flush
2021-01-22 Software: changed Sin definition in SR Asic write
2021-01-22 Software: Improved Nexys IO WriteASIC interface, verified pattern being send
2021-01-22 Software: Changed Send Load Sequence in WriteASIC to match simple direct to chip sequencing
2021-01-22 Software: Removed unclear code
2021-01-22 Software: Changed load send for asic config to SendLoad
2021-01-22 Software: Debugging SR behavior
2021-01-22 Software: Fixed SR writing
2021-01-22 Software: Added clkdiv argument to SendLoad
2021-01-23 Software: Don't create QWidget for unused IDACs and Extrabits
2021-01-23 Software: GUI Injection output fixed to GECCO
2021-01-24 Firmware: Chip Config Debug output on PMOD connector JB Pins 1-4
2021-01-25 Firmware: Single Ended Chip config for sin, ck1 and ld
2021-01-26 Firmware: Fix the mix-up between OUT:res_n and IN:interrupt, which holds chipconfig in reset state
2021-01-27 Firmware: Fix the mix-up between OUT:res_n and IN:interrupt
    Fix the mix-up between OUT:res_n and IN:interrupt, which holds chipconfig in reset state
2021-01-27 Software: Changed default vaule for Vth
2021-01-29 SW: Added API to localhost:8090 per default to test (will make this configurable)
2021-01-29 SW: removed config value change logging for debuggin purpose
2021-01-29 SW: API /asic/config/@send "clicks" on Update asic button. If not Nexys is connected the SR bit write runs and prints debugging, but nothing is written to device
2021-01-30 Firmware: Debug: Control res_n with center button
2021-01-31 Fixing issue #2 , unused Config elements insert a null widget reference in the model
2021-01-31 Firmware: Chip Config completely single-ended
2021-01-31 Firmware: Prepare Res_n Configuration via Software
2021-01-31 Software: Workaround for failed subsequent Config Updates
    This workaround writes zeros into the SR with Res_N low, before writing the actual config.
    res_n replaces SinB in Register 0:4
    (Works only with modified Firmware from unhappy branch)
2021-02-03 Software: Workaround: select injection output on GUI
    To enable correct output, the injection output must be set to Atlaspix and then to GECCO
2021-02-03 Software: Add Load DACs for Voltage and Injectionboards
    This should fix the problem of writing configs to the wrong boards.
2021-02-03 Firmware: vb_config Debug Output on PMOD JC
2021-02-04 PCB: Rev1.1
    - Connect outer Guardrings from Pads and Digital to HV by Bonding 42 to HV Pad
    - Remove powerrail short
    - Move Inj Pin from C5_4 to C5_1
    - Changed external Pullup Resistors to 100k
    - Removed VSSA
2021-02-06 Firmware: Set Diff sample_clk constant 1 and remove unused 10 Mhz cmd clock
2021-02-06 Software: Configure 2nd unused output on Injection Board
2021-02-08 PCB: Small cleanup for Rev1.1
2021-02-15 PCB: Updated Bondplan
2021-02-19 Software: Reduce Asicconfig clkspeed
2021-02-19 Software: Updated DAC default values
2021-02-19 Firmware: MMCM 220MHz differential sample_clk
2021-02-23 Added STL for 3D Printed lid
2021-02-25 Firmware: Revert Single-ended Chip Config
2021-02-25 Firmware: Revert Single-ended Chip Config 2
    Uncomment differential outputs
2021-02-25 Firmware: Latest bitstream for Nexys Video(includes cfb37e9)
2021-02-27 Software: Add Python Interface to qt-httpserver
2021-03-03 PCB: Updated Bondplan PDF
2021-03-11 Firmware: Code Cleanup
    -Removed unused I/O, module instantiations and Comments
    -Added global define "config_singleended" to have a single firmware for both single and differential ASIC SRconfig
2021-03-11 QT Software: Reorganised structure. The main QT project is now gecco_software_top.pro, which compiles Astropix software and qthttpserver together
2021-03-18 Moved Readme with most software building instructions to Astropix v1 top folder
2021-03-25 Software: Add Injection to API
    Start/Update: http://127.0.0.1:8090/asic/injection/start/0.5/300/100/300
    Params: start/<voltage>/<delay>/<period>/<clkdiv>
    Stop: http://127.0.0.1:8090/asic/injection/stop
2021-03-31 FW: Status LEDs
    LED1: res_n
    LED2: SPI_CS
    LED3: spi_write_fifo_empty
2021-03-31 FW: SPI Module update
2021-04-06 Update README.md
    IVI Compliance Package needed for lasercontrol module (to be removed in a future release)
2021-05-09 SW: Basic check if FPGA is programmed
2021-05-16 SW: Don't create label for Load signals in voltageboard window
2021-05-16 Update README firmware section
2021-05-25 PCB: Delete old Bondplan
2021-06-18 Update .gitignore for KiCad project
2021-06-18 Initial commit of Astropix2 KiCad project
2021-06-23 PCB: Updated Astropix2 schematic
2021-06-23 Updated 3D Folder for AstroPix2
2021-06-24 SW: Removed fastreadout
2021-06-24 SW: Removed Lasercontrol and VISA
    -Removed unused functions
    -Restored fastreadout lib files
2021-06-24 SW: Removed unnecessary files
2021-06-24 SW: Fixed bug with injection output
    -Fixed initial missmatch between GUI and backend
2021-06-25 Update asicconfig_http.py
    Updated asicconfig_http.py from nic-str/astropix-test
2021-07-07 Updated Schematic and Asic footprint
2021-07-08 PCB: First astropix2 layout
2021-07-09 PCB: Updated Footprints
2021-07-09 PCB: Updated astropix2 pcb
    -diff pair impedance
    -added teardropds
    -small fixes
2021-07-09 PCB: Cosmetic Fixes
2021-07-12 PCB: Small corrections
2021-07-22 PCB: Apix v2 updates
    - Added SPI series resistors
    - connected spi_right_clk to FMC
    - Updated Amplifier Layout
2021-07-24 FW: Simple fix for CDC timing fail
    - Use same clock for patgen and ftdi, 100 MHz is sufficient for Astropix Hitrates
2021-07-24 FW: Added Reset value for spi_read_fifo
    - Undefined spi_read_fifo_rdcount caused SPI read_data <= 8'hff;
2021-07-24 FW: Fixed spi_read_fifo enable always low
    - Wrong address 23 in spi_read_fifo enable assertion, caused enable to stay always low
2021-07-25 FW: Update v1 SPI Readout
    - Fixed spi module (see also de94172 and 1d7eae7)
    - Changed MISO pin type
    - Fixed writeFIFO wire width
    - Added some comments
2021-07-26 FW: Copied v1 FW for v2
2021-07-26 FW: Update v1 FW for reorganized structure
2021-07-26 FW: SPI Module for Astropix2 miso0, miso1
    - Updated SPI Module
    - Added rudimentary tb
2021-07-26 FW: Added vivado gitignore
2021-07-27 FW: Update Pins for v2
2021-07-27 FW: Update v2 IP
2021-07-27 FW: Cleanup v2
    - Removed unused ip
    - fixed mmcm output names
2021-07-27 PCB: Added holes for HIT bonding fixture
2021-08-04 PCB V2: Connected SR_out/RB + Updated production files
2021-08-04 PCB V2: Updated pdf schematic
2021-08-04 FW: Moved v1 Firmware to FW folder
2021-08-04 PCB V2: Updated Teardrops
2021-08-12 PCB v2: Added markings for Bonding
    -Updated gerber and assembly files
2021-08-16 PCB v1: Added Gerber Files
2021-08-16 PCB v1: Fixed floating SR_RB and updated gerbers
2021-09-23 FW V2: Added config Readback output and Sout input
    - Added Readback bit 5 to ASIC Config Register 0
2021-10-06 SW V1: visa ivi package not needed anymore
2021-10-06 SW V1: fixed typo
2021-11-15 3D: Astropix2 chip cover
2021-11-17 3D: Astropix2 thicker walls
2021-11-19 SW: Inital Astropix2 Software commit
2021-11-19 SW: Astropix Readme update
2021-12-20 SW V2: Updated nexysio WriteAsic function for large config vectors
2022-01-04 Top, SPI, Constraints: see details below
    - Top: Added Timestampclk_div2, fixed port directions
    - updated constraints
    - SPI: added continous write until WriteFifo is empty
    - SPI: write/read leading/trailing edge
2022-01-25 FW2: Fixed bug which prevented chip configuration with standard GECCO board
2022-03-13 FW2: Added FIFO and FTDI Register 60+61 for SOut readback
2022-03-13 FW2: SR readback added missing resetvalue
2022-03-27 SR Readback: Fixes
2022-12-21 PCB: AstroPix3 carrier WIP
2022-12-22 PCB: Astropix3 updates
2023-01-09 PCB: Astropix3 update
2023-01-13 PCB: Added AstroPix3 quadchip schematic
2023-02-01 PCB: Added final V3 PCB with fabrication data
2023-02-01 PCB: Connected HV Pad
2023-02-06 FW: Updated SPI readout on interrupt
2023-02-10 PCB: V3 improvements
2023-05-23 FW: AstroPix3 Firmware
2023-05-24 FW: Telescope V2 fixed fast clock pins
2023-07-12 FW V2: Automatic SPI readout on interrupt
2023-07-20 FW2: Changed default to differential SR config
2023-07-20 FW V3: Implemented SPI updates from V2
2023-08-18 FW2: Fixed constraints for diff chip config
2023-09-14 Fw: TCL constraints, spi readout updates
2023-09-14 FW: Revert changes in NexysVideo_Master.xdc
2023-09-14 TCL: Fixed errors
2023-09-14 FW: Removed config from xpr
2023-09-28 PCB: WIP AstroPix4
2023-09-29 PCB: AstroPix4 v1 \w production files + bondplan
2023-09-29 PCB: V4 added schematic
2026-02-04 Astropix 5 PCB first draft
2026-02-04 remodif
2026-02-06 modif v5
2026-02-06 Updated KiCAD .gitignore, removed old backup files
2026-02-23 Schematic draft 2
2026-03-06 Small modifications in schematic and layout finished
2026-03-25 Layout change schematic pcie change
2026-04-08 Commit with all the files
2026-04-20 all files on git
